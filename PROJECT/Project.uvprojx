# Keil uVision project Project.uvprojx, settings and files
target PROJECT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD ,USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\CMSIS;..\HARDWARE\Track;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\io;..\HARDWARE\MOTOR;..\HARDWARE\Encoder;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\UART;..\HARDWARE\BEEP;..\HARDWARE\LobotServoController;..\HARDWARE\LobotServoController\uart;..\HARDWARE\Sensor_infrared;..\HARDWARE\Remote;..\APP\bsp_sys;..\APP\Process;..\APP\RobotArm;..\APP\TIMER;..\APP\TIMER;..\APP\Track;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group APP
    ../APP/bsp_sys/: bsp_sys.c
    ../APP/RobotArm/: RobotArm.c
    ../APP/TIMER/: timer.c timer.h
    ../APP/Track/: Track.h Track.c
  group HARDWARE
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/: mpuiic.c
    ../HARDWARE/LobotServoController/: LobotServoController.c
    ../HARDWARE/LobotServoController/uart/: uart.c
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/Encoder/: Encoder.c
    ../HARDWARE/MOTOR/: speed_PWM.c motor.c motor.h
    ../HARDWARE/Sensor_infrared/: IIC.c sensor_infrared.c
    ../HARDWARE/Remote/: Remote.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group README
    ./: readme.txt
